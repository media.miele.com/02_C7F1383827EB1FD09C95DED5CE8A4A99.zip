Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 80e01263-0c2f-4f95-905a-cd8f95545a0f, NumberOfSaves: 1]
File name: 0001
Time: 2025-07-28T12:24:24+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11605210_EP3_PFD102i_ED:61010201_EP3_11605210_PFD102i_ED, (2)
In: Default
Type - Material: z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 61010201_EP3_11605210_PFD102i_ED; sets with these values: 2

# IfcDistributionPort, Port_356522_1
Description: Flow; FlowDirection: SOURCEANDSINK
